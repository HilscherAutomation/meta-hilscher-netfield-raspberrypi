CMDLINE_ROOTFS = "dwc_otg.lpm_enable=0 console=tty1 logo.nologo dwc_otg.fiq_enable=0 dwc_otg.fiq_fsm_enable=0"

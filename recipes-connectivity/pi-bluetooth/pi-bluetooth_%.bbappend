# For some reason bluetooth initialization fails. Until it is correcty disable autostart
# as we are currently not using it anyway
SYSTEMD_AUTO_ENABLE ?= "disable"

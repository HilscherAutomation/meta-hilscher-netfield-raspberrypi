COMPATIBLE_HOST = "arm-.*-linux"

PACKAGE_INSTALL:append = " device-tree "
